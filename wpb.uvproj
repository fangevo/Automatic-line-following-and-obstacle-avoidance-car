# Keil uVision project wpb.uvproj, settings and files
target WPB (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: wpb
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\STM32_Lib\STM32F10x_StdPeriph_Driver\inc;.\STM32_Lib\CMSIS\CM3\CoreSupport;.\STM32_Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\WPB_Lib;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ./STM32_Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
  group USER
    ./User/: main.c
  group STM32_LIB
    ./STM32_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./STM32_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group WPB_LIB
    ./WPB_Lib/: inv_mpu.c inv_mpu_dmp_motion_driver.c Queue.c stdlib.c Wp_25F16.c Wp_ADC.c Wp_Ble.c Wp_Dma.c Wp_EXTI.c Wp_Flash.c Wp_Globle.c Wp_GPIO.c Wp_HallSensor.c Wp_IIC.c Wp_it.c Wp_Key.c Wp_Motor.c Wp_MPU6050.c Wp_NVIC.c Wp_OLED.c Wp_Pwm.c Wp_Sys.c Wp_TIMER.c Wp_UART.c
  group STARTUP
    ./STM32_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
